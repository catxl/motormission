# Keil uVision project GD32303C_EVAL.uvprojx, settings and files
target GD32F303C_EVAL (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: GD32F303VC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD
  c include: ..\GD32F30x_Firmware_Library\CMSIS;..\GD32F30x_Firmware_Library\CMSIS\GD\GD32F30x\Include;..\GD32F30x_Firmware_Library\GD32F30x_standard_peripheral\Include;..\;..\io;..\processor;..\worker;..\public;..\driver;..\mission;..\public_extern
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application
    ../: main.c gd32f30x_it.c comm_proc.c utils.c
  group public
    ../public/: public_comm_buffer.c public_photosensors.c public_step_motors.c public_usart_io.c public_valves.c public_timers.c public_switches.c public_actions.c public_indicators.c public_missions.c public_common_motors.c public_dc_motors.c public_detectors.c public_utils.c
  group public_extern
    ../public_extern/: public_actions_extern.c public_indicators_extern.c public_detectors_extern.c public_common_motors_extern.c
  group mission
    ../mission/: all_missions.c mission_common_motor_init.c mission_common_motor_move.c mission_demo_action.c
  group processor
    ../processor/: cmd_proc_func.c sensor_counter_processors.c cmd_proc_share_func.c
  group worker
    ../worker/: lcds.c leds.c photosensors.c step_motors.c switches.c valves.c timers.c common_motors.c dc_motors.c detectors.c
  group io
    ../io/: can_io.c comm_buffer.c commpacket.c eeprom.c protocol.c usart_io.c byte_sequence.c
  group CMSIS
    ../GD32F30x_Firmware_Library/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group GD32F30x_Peripherals
    ../GD32F30x_Firmware_Library/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group Startup
    ../GD32F30x_Firmware_Library/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
  group Doc
    ../: readme.txt
